# Keil uVision project MDKV540.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MDKV540
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./Source/: main.c app.c gpio-interface.c led-interface.c uart-interface.c modbus-crc16.c uart-interface.h modbus-rtu-slave.c mbrtuslave.c mbrtu.c mbcommon.c mbcommon.h mbrtu.h mbpdu.h mbtable.c mbpdu.c
software components: CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, CMSIS Driver:USART 2.3, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0
